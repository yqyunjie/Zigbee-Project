# IAR project sensor-avr.ewp, settings and files
configuration Sensor-Atmega128 (AVR)
  General.LCHeapSize: 0
  General.SCCStackSize: 0x300
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: PLATFORM_HEADER="hal/micro/avr-atmega/compiler/iar.h"; PHY_EM2420; BOARD_DEV0222; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; SENSOR_APP; AVR_ATMEGA; AVR_ATMEGA_128; BOARD_HEADER="hal/micro/avr-atmega/128/board/dev0222.h"; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; UPGRADE_NODE_AND_CLASSIC_TOKENS
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.IExtraOptions: --string_literals_in_flash
  ICCAVR.newCCIncludePaths: ..\..\; ..\..\STACK\; ..\..\HAL\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  postbuild: "..\..\tool\etrim\etrim.exe"  "$TARGET_DIR$\$TARGET_FNAME$"
  XLINK.XclFile: ..\..\hal\micro\avr-atmega\128\app-cfg.xcl
  XLINK.XExtraOptions: -y(CODE) -w6
configuration Sink-Atmega128 (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: PLATFORM_HEADER="hal/micro/avr-atmega/compiler/iar.h"; PHY_EM2420; BOARD_DEV0222; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; SINK_APP; AVR_ATMEGA; AVR_ATMEGA_128; BOARD_HEADER="hal/micro/avr-atmega/128/board/dev0222.h"; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; UPGRADE_NODE_AND_CLASSIC_TOKENS
  postbuild: "..\..\tool\etrim\etrim.exe" "$TARGET_DIR$\$TARGET_FNAME$"
configuration Sensor-Atmega128-Debug (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: PLATFORM_HEADER="hal/micro/avr-atmega/compiler/iar.h"; PHY_EM2420; BOARD_DEV0222; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; SENSOR_APP; DEBUG; EMBER_SERIAL0_DEBUG; AVR_ATMEGA; AVR_ATMEGA_128; BOARD_HEADER="hal/micro/avr-atmega/128/board/dev0222.h"; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"
  postbuild: as above
configuration Sink-Atmega128-Debug (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: PLATFORM_HEADER="hal/micro/avr-atmega/compiler/iar.h"; PHY_EM2420; BOARD_DEV0222; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; SINK_APP; DEBUG; EMBER_SERIAL0_DEBUG; AVR_ATMEGA; AVR_ATMEGA_128; BOARD_HEADER="hal/micro/avr-atmega/128/board/dev0222.h"; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"
  postbuild: as above
configuration Sleepy-Sensor-Atmega128 (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: PLATFORM_HEADER="hal/micro/avr-atmega/compiler/iar.h"; PHY_EM2420; BOARD_DEV0222; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; SLEEPY_SENSOR_APP; AVR_ATMEGA; AVR_ATMEGA_128; BOARD_HEADER="hal/micro/avr-atmega/128/board/dev0222.h"; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; UPGRADE_NODE_AND_CLASSIC_TOKENS
configuration Mobile-Sensor-Atmega128 (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: PLATFORM_HEADER="hal/micro/avr-atmega/compiler/iar.h"; PHY_EM2420; BOARD_DEV0222; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; MOBILE_SENSOR_APP; AVR_ATMEGA; AVR_ATMEGA_128; BOARD_HEADER="hal/micro/avr-atmega/128/board/dev0222.h"; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; UPGRADE_NODE_AND_CLASSIC_TOKENS
  group app-util
    ../util/common/: form-and-join-node-adapter.c form-and-join-node-callbacks.c form-and-join.c
    ../util/security/: node.c
    ../util/serial/: serial.c
  group Hal
    ../../hal/: ember-configuration.c
  group Hal/micro/avr
    ../../hal/micro/avr-atmega/: adc.c button.c buzzer.c em2420.c led.c spi.c token.c uart.c
  group Hal/micro/avr/128
    ../../hal/micro/avr-atmega/128/: bootloader-interface-app.c bootloader-interface-standalone-120k.c cstartup.s90 diagnostic.c em2420-128.c low-level-init.c micro.c symbol-timer.c system-timer.c
  group Hal/micro/generic
    ../../hal/micro/generic/: mem-util.c random.c
  group SensorGroup
    ./: sensor.c
  group SinkGroup
    ../util/security/: security-address-cache.c trust-center.c
    ./: sink.c
    ../util/: source-route-common.c source-route.c
  group Sleepy-Sensor
    ./: sleepy-sensor.c
  group stack/Stack-Atmega128
    ../../stack/build/: alarm-library-em2420-mega128.r90 binding-table-library-em2420-mega128.r90 cbke-stub-library-em2420-mega128.r90 end-device-bind-stub-library-em2420-mega128.r90 security-library-core-em2420-mega128.r90 security-library-link-keys-stub-em2420-mega128.r90 zigbee-pro-stack-em2420-mega128.r90
  group stack/Stack-Atmega128-Debug
    ../../stack/build/: alarm-library-em2420-mega128-debug.r90 binding-table-library-em2420-mega128-debug.r90 cbke-stub-library-em2420-mega128-debug.r90 end-device-bind-stub-library-em2420-mega128-debug.r90 security-library-core-em2420-mega128-debug.r90 security-library-link-keys-stub-em2420-mega128-debug.r90 zigbee-pro-stack-em2420-mega128-debug.r90
  group Utilities
    ./: common.c
