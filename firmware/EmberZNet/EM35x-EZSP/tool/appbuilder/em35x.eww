<?xml version="1.0" encoding="iso-8859-1"?>
<!-- THIS IS A GENERATED FILE: PLEASE DO NOT EDIT -->

<workspace>
  <project>
    <path>$WS_DIR$\_replace_projectName_.ewp</path>
  </project>
  <batchBuild/>
</workspace>
