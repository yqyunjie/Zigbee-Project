# IAR project mfg-sample-host.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_HEADER="hal/host/cortexm3/stm32f103ret/null.h"; PLATFORM_HEADER="hal/host/cortexm3/stm32f103ret/compiler/iar-st.h"; HAL_HOST; STM32F10X_HD; USE_STDPERIPH_DRIVER; EMBER_SERIAL_USE_STDIO; CONFIGURATION_HEADER="app/mfglib-host/mfg-host-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EZSP_HOST; EMBER_SERIAL0_DEBUG; APP_SERIAL=0; EZSP_APPLICATION_HAS_MFGLIB_HANDLER; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 3
  ICCARM.CCIncludePath2: $FILE_DIR$; ../../..; ../../../stack; ../../../HAL; ../../../../../base/rel-znet-5.0; ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../../hal/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc; ../../../hal/host/cortexm3/stm32f103ret; ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../../hal/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_HEADER="hal/host/cortexm3/stm32f103ret/null.h"; PLATFORM_HEADER="hal/host/cortexm3/stm32f103ret/compiler/iar-st.h"; HAL_HOST; STM32F10X_HD; USE_STDPERIPH_DRIVER; EMBER_SERIAL_USE_STDIO; CONFIGURATION_HEADER="app/mfglib-host/mfg-host-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EZSP_HOST; EMBER_SERIAL0_DEBUG; APP_SERIAL=0; EZSP_APPLICATION_HAS_MFGLIB_HANDLER
  AARM.AUserIncludes: $FILE_DIR$; ../../..; ../../../stack; ../../../hal; ../../../host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../../host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../../host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc; ../../../hal/host/cortexm3/stm32f103ret; ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../../hal/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc
  OBJCOPY.OOCOutputFile: mfg-sample-host.s37
  ILINK.IlinkOutputFile: mfg-sample-host.out
  ILINK.IlinkIcfFile: ../../../hal/host/cortexm3/stm32f103ret/iar-cfg-st.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: mfg-sample-host.c mfg-sample-tokens.c
  group app
    ../../util/serial/: cli.c serial.c
    ../../util/ezsp/: serial-interface-spi.c
  group ezsp
    ../../util/ezsp/: ezsp-callbacks.c ezsp-frame-utilities.c ezsp-utils.c ezsp.c
  group hal/host/cm3/stm32
    ../../../hal/host/cortexm3/stm32f103ret/: adc.c button.c buzzer.c led.c micro.c spi-protocol.c system-timer.c uart.c
  group hal/host/cm3/stm32/cmsis
    ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group hal/host/cm3/stm32/device
    ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group hal/host/cm3/stm32/STM32F10x_StdPeriph_Driver
    ../../../hal/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal/host/generic
    ../../../hal/host/generic/: crc.c
