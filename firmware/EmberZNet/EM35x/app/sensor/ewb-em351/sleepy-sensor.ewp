# IAR project sleepy-sensor.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM351; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SLEEPY_SENSOR_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE; USE_BOOTLOADER_LIB; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM351; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SLEEPY_SENSOR_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE; USE_BOOTLOADER_LIB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepy-sensor.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: sleepy-sensor.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em351/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c sleep.c token-def.c token.c uart.c
    ../../../build/alarm-library-cortexm3-iar-em351-em3xx/: alarm-library.a
    ../../../build/binding-table-library-cortexm3-iar-em351-em3xx/: binding-table-library.a
    ../../util/bootload/: bootload-utils.c
    ../../../build/cbke-stub-library-cortexm3-iar-em351-em3xx/: cbke-stub-library.a
    ../: common.c sleepy-sensor.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../hal/: ember-configuration.c
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em351-em3xx/: end-device-bind-stub-library.a
    ../../util/common/: form-and-join-node-adapter.c form-and-join-node-callbacks.c form-and-join.c
    ../../../build/hal-library-cortexm3-iar-em351-em3xx/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em351-em3xx/: install-code-library-stub.a
    ../../../hal/micro/cortexm3/em35x/em351/: mpu.c
    ../../../build/multi-network-stub-library-cortexm3-iar-em351-em3xx/: multi-network-stub-library.a
    ../../util/security/: node.c security-common.c
    ../../../build/packet-validate-stub-library-cortexm3-iar-em351-em3xx/: packet-validate-stub-library.a
    ../../../build/security-library-core-end-device-cortexm3-iar-em351-em3xx/: security-library-core-end-device.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em351-em3xx/: security-library-link-keys-stub.a
    ../../util/serial/: serial.c
    ../../../build/zigbee-pro-leaf-stack-cortexm3-iar-em351-em3xx/: zigbee-pro-leaf-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em351-em3xx/: zll-stub-library.a
