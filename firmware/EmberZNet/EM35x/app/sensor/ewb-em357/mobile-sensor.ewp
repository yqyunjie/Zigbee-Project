# IAR project mobile-sensor.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EM357 Ember EM357
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; MOBILE_SENSOR_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; MOBILE_SENSOR_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mobile-sensor.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: mobile-sensor.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../: common.c sleepy-sensor.c
  group APP/UTIL
    ../../util/common/: form-and-join-node-adapter.c form-and-join-node-callbacks.c form-and-join.c
    ../../util/security/: node.c security-common.c
    ../../util/serial/: serial.c
  group HAL
    ../../../hal/: ember-configuration.c
  group HAL/MICRO/CM3
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c sleep.c token-def.c token.c uart.c
  group HAL/MICRO/CM3/EM357
    ../../../hal/micro/cortexm3/em35x/em357/: mpu.c
  group HAL/MICRO/Generic
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
  group LIB
    ../../../build/alarm-library-cortexm3-iar-em357-em3xx/: alarm-library.a
    ../../../build/binding-table-library-cortexm3-iar-em357-em3xx/: binding-table-library.a
    ../../../build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em357-em3xx/: end-device-bind-stub-library.a
    ../../../build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em357-em3xx/: packet-validate-library.a
    ../../../build/security-library-core-end-device-cortexm3-iar-em357-em3xx/: security-library-core-end-device.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em357-em3xx/: security-library-link-keys-stub.a
    ../../../build/zigbee-pro-leaf-stack-cortexm3-iar-em357-em3xx/: zigbee-pro-leaf-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
