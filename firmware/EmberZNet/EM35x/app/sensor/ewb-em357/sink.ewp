# IAR project sink.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EM357 Ember EM357
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=128; EMBER_SERIAL0_RX_QUEUE_SIZE=64; SCAN_DEBUG_PRINT_ENABLE; USE_BOOTLOADER_LIB; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=128; EMBER_SERIAL0_RX_QUEUE_SIZE=64; SCAN_DEBUG_PRINT_ENABLE; USE_BOOTLOADER_LIB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sink.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: sink.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../: common.c sink.c
  group APP/Util
    ../../util/common/: form-and-join-node-adapter.c form-and-join-node-callbacks.c form-and-join.c
    ../../util/security/: security-address-cache.c security-common.c trust-center.c
    ../../util/serial/: serial.c
    ../../util/: source-route-common.c source-route.c
  group HAL
    ../../../hal/: ember-configuration.c
  group HAL/Micro/CM3
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c sleep.c token-def.c token.c uart.c
    ../../util/bootload/: bootload-utils.c
  group HAL/Micro/CM3/EM357
    ../../../hal/micro/cortexm3/em35x/em357/: mpu.c
  group HAL/Micro/Generic
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
  group LIB
    ../../../build/alarm-library-cortexm3-iar-em357-em3xx-debug/: alarm-library.a
    ../../../build/binding-table-library-cortexm3-iar-em357-em3xx-debug/: binding-table-library.a
    ../../../build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em357-em3xx/: end-device-bind-stub-library.a
    ../../../build/hal-library-cortexm3-iar-em357-em3xx-debug/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em357-em3xx-debug/: packet-validate-library.a
    ../../../build/security-library-core-cortexm3-iar-em357-em3xx-debug/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em357-em3xx/: security-library-link-keys-stub.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-em357-em3xx-debug/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
