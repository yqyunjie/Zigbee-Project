# IAR project standalone-bootloader-demo-v2.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: ENABLE_BOOTLOAD_PRINT; DEBUG; BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM351; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/standalone-bootloader-demo/bootloader-demo-v2-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=128; EMBER_SERIAL0_RX_QUEUE_SIZE=64; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ENABLE_BOOTLOAD_PRINT; DEBUG; BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM351; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/standalone-bootloader-demo/bootloader-demo-v2-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=128; EMBER_SERIAL0_RX_QUEUE_SIZE=64
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: standalone-bootloader-demo-v2.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: standalone-bootloader-demo-v2.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em351/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c sleep.c token-def.c token.c uart.c
    ../../../build/alarm-library-cortexm3-iar-em351-em3xx-debug/: alarm-library.a
    ../../../build/binding-table-stub-library-cortexm3-iar-em351-em3xx/: binding-table-stub-library.a
    ../../../app/util/bootload/: bootload-utils.c
    ../../../app/standalone-bootloader-demo/: bootloader-demo-v2.c
    ../../../build/cbke-stub-library-cortexm3-iar-em351-em3xx/: cbke-stub-library.a
    ../../../app/util/serial/: command-interpreter2.c serial.c
    ../../../app/util/common/: common-onboard.c common.c form-and-join-node-adapter.c form-and-join-node-callbacks.c form-and-join.c library.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../hal/: ember-configuration.c
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em351-em3xx/: end-device-bind-stub-library.a
    ../../../build/hal-library-cortexm3-iar-em351-em3xx-debug/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em351-em3xx/: install-code-library-stub.a
    ../../../hal/micro/cortexm3/em35x/em351/: mpu.c
    ../../../build/multi-network-stub-library-cortexm3-iar-em351-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-stub-library-cortexm3-iar-em351-em3xx/: packet-validate-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-em351-em3xx-debug/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em351-em3xx-debug/: security-library-link-keys-stub.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-em351-em3xx-debug/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em351-em3xx/: zll-stub-library.a
